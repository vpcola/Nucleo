# Keil uVision project Nucleo_blink_led.uvproj, settings and files
target mbed NUCLEO_F401RE (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_blink_led
  AfterMake: fromelf --bin -o build\Nucleo_blink_led_NUCLEO_F401RE.bin build\Nucleo_blink_led.axf
  c flags: Optim=1
  c define: TARGET_NUCLEO_F401RE,  TARGET_M4,  TARGET_STM,  TARGET_STM32F4,  TARGET_STM32F401RE,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1408874015.43,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;DHT;mbed-src;mbed-src/hal;mbed-src/api;mbed-src/targets;mbed-src/targets/hal;mbed-src/targets/hal/TARGET_STM;mbed-src/targets/hal/TARGET_STM/TARGET_NUCLEO_F401RE;mbed-src/targets/cmsis;mbed-src/targets/cmsis/TARGET_STM;mbed-src/targets/cmsis/TARGET_STM/TARGET_NUCLEO_F401RE;mbed-src/targets/cmsis/TARGET_STM/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO;mbed-src/common;mbed-rtos/rtos;mbed-rtos/rtx;SDFileSystem;SDFileSystem/FATFileSystem;SDFileSystem/FATFileSystem/ChaN;CC3000;CC3000/Socket;CC3000/Helper;ILI9341
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: mbed-src/targets/cmsis/TARGET_STM/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO/stm32f401xe.sct
  group src
    ./: main.cpp
    ./: Shell.cpp Utility.cpp ini.c HttpClient.cpp JsonParser.cpp
  group DHT
    DHT/: DHT.cpp
  group mbed
    mbed-src/targets/cmsis/TARGET_STM/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO/: startup_stm32f401xe.s sys.cpp
    mbed-src/targets/cmsis/TARGET_STM/TARGET_NUCLEO_F401RE/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma_ex.c system_stm32f4xx.c stm32f4xx_hal_can.c stm32f4xx_hal_hcd.c stm32f4xx_hal_sai.c stm32f4xx_hal_nor.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_crc.c hal_tick.c cmsis_nvic.c stm32f4xx_hal_irda.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cryp.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_sram.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_hash.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_sd.c stm32f4xx_hal_pccard.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_tim.c stm32f4xx_hal_nand.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cryp_ex.c
    mbed-src/targets/hal/TARGET_STM/TARGET_NUCLEO_F401RE/: spi_api.c analogin_api.c gpio_api.c rtc_api.c gpio_irq_api.c serial_api.c mbed_overrides.c pwmout_api.c i2c_api.c sleep.c pinmap.c us_ticker.c port_api.c
    mbed-src/common/: board.c assert.c mbed_interface.c us_ticker_api.c exit.c rtc_time.c pinmap_common.c error.c gpio.c semihost_api.c wait_api.c RawSerial.cpp Ticker.cpp FilePath.cpp I2C.cpp FileBase.cpp retarget.cpp Serial.cpp Stream.cpp FileSystemLike.cpp CallChain.cpp InterruptManager.cpp SerialBase.cpp BusInOut.cpp SPISlave.cpp I2CSlave.cpp FunctionPointer.cpp Timer.cpp SPI.cpp Timeout.cpp Ethernet.cpp TimerEvent.cpp CAN.cpp BusOut.cpp FileLike.cpp BusIn.cpp InterruptIn.cpp LocalFileSystem.cpp
  group mbed-rtos
    ./mbed-rtos/rtos/: Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
    ./mbed-rtos/rtx/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c RTX_Conf_CM.c
    ./mbed-rtos/rtx/TARGET_M4/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.s
  group SDFileSystem
    ./SDFileSystem/: SDFileSystem.cpp
    ./SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp ff.cpp
  group CC3000
    ./CC3000/: cc3000.cpp cc3000_event.cpp cc3000_hci.cpp cc3000_netapp.cpp cc3000_nvmem.cpp cc3000_security.cpp cc3000_socket.cpp cc3000_spi.cpp cc3000_wlan.cpp cc3000_simplelink.cpp
    ./CC3000/Socket/: Endpoint.cpp Socket.cpp TCPSocketConnection.cpp TCPSocketServer.cpp UDPSocket.cpp
  group ILI9341
    ./ILI9341/: GraphicsDisplay.cpp SPI_TFT_ILI9341.cpp SPI_TFT_ILI9341_NUCLEO.cpp SPI_TFT_ILI9341_NXP.cpp TextDisplay.cpp
